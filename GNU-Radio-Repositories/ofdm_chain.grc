options:
  parameters:
    generate_options: qt_gui
    id: ofdm_chain
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: RXOFDM_synch_and_chan_est_0
  id: RXOFDM_synch_and_chan_est
  parameters:
    cp_len: '16'
    diagnostics: '1'
    directory_name: |
      /srv/LTE-GNU-Radio-Code/DATA/
    file_name_cest: output_file
    genie: '1'
    nfft: '64'
    num_data_bins: '60'
    num_ofdm_symb: '24'
    num_synch_bins: '64'
    snr: '50'
    synch_dat: '[1, 3]'
  states: {}
- name: TXOFDM_tx_signal_transmitter_0
  id: TXOFDM_tx_signal_transmitter
  parameters:
    case: '0'
    pickle_directory: /srv/LTE-Code-Offline/Data/
    pickle_file: tx_data_offline.pckl
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}

connections:
- [RXOFDM_synch_and_chan_est_0, '0', blocks_null_sink_0, '0']
- [TXOFDM_tx_signal_transmitter_0, '0', RXOFDM_synch_and_chan_est_0, '0']

metadata:
  file_format: 1
