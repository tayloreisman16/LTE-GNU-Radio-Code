options:
  parameters:
    generate_options: qt_gui
    id: ofdm_chain
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: utsa_ofdm_SynchAndChanEst_0
  id: utsa_ofdm_SynchAndChanEst
  parameters:
    channel: ''
    cp_len: ''
    diagnostics: ''
    directory_name: ''
    file_name_cest: ''
    genie: ''
    nfft: ''
    num_data_bins: ''
    num_ofdm_symb: ''
    num_synch_bins: ''
    scale_factor_gate: ''
    snr: ''
    synch_dat: ''
  states: {state: bypassed}
- name: utsa_ofdm_TxSignalTransmitter_0
  id: utsa_ofdm_TxSignalTransmitter
  parameters:
    case: ''
    pickle_directory: /srv/LTE-Code-Offline/Data/
    pickle_file: tx_data_online_chan_type_Fading_SNR_100.pckl
  states: {}

connections:
- [utsa_ofdm_SynchAndChanEst_0, '0', blocks_null_sink_0, '0']
- [utsa_ofdm_TxSignalTransmitter_0, '0', utsa_ofdm_SynchAndChanEst_0, '0']

metadata:
  file_format: 1
