<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft1</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>OFDMTransmitter_OFDMTransmitter</key>
<param><key>id</key><value>OFDMTransmitter_OFDMTransmitter_0</value></param>
<param><key>case</key><value>9</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>256</value></param>
<param><key>num_data_bins</key><value>128</value></param>
<param><key>num_ofdm_symb</key><value>24</value></param>
</block>
<block>
<key>OFDMTransmitter_OFDMTxWithTimer</key>
<param><key>id</key><value>OFDMTransmitter_OFDMTxWithTimer_0</value></param>
<param><key>case</key><value>9</value></param>
</block>
<block>
<key>OFDMTransmitter_SimpleTx</key>
<param><key>id</key><value>OFDMTransmitter_SimpleTx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>txOFDM_ConstellationModulation</key>
<param><key>id</key><value>txOFDM_ConstellationModulation_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>modulation</key><value>"QPSK"</value></param>
</block>
<block>
<key>txOFDM_CyclicPrefix</key>
<param><key>id</key><value>txOFDM_CyclicPrefix_0</value></param>
<param><key>cp_size</key><value>fft1/4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>fft1</value></param>
</block>
<block>
<key>txOFDM_IFFT</key>
<param><key>id</key><value>txOFDM_IFFT_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>fft1</value></param>
</block>
<block>
<key>txOFDM_OFDM_Modulation</key>
<param><key>id</key><value>txOFDM_OFDM_Modulation_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>fft1</value></param>
<param><key>pilot_locations</key><value>[-21, -7, 7, 21]</value></param>
</block>
<block>
<key>txOFDM_SynchDataMux</key>
<param><key>id</key><value>txOFDM_SynchDataMux_0</value></param>
<param><key>cp_size</key><value>fft1/4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fft_size</key><value>fft1</value></param>
<param><key>prime_no</key><value>47</value></param>
<param><key>synch_every</key><value>3</value></param>
<param><key>synch_length</key><value>fft1-2</value></param>
</block>
<block>
<key>txOFDM_random_bit_source</key>
<param><key>id</key><value>txOFDM_random_bit_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>3.84e6</value></param>
<param><key>center_freq0</key><value>2.2e9</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>5</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>stream_args</key><value>peak=0.003906</value></param>
<param><key>sync</key><value>pc_clock</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>OFDMTransmitter_OFDMTransmitter_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>OFDMTransmitter_OFDMTxWithTimer_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>OFDMTransmitter_SimpleTx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>txOFDM_ConstellationModulation_0</source_block_id><sink_block_id>txOFDM_OFDM_Modulation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>txOFDM_CyclicPrefix_0</source_block_id><sink_block_id>txOFDM_SynchDataMux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>txOFDM_IFFT_0</source_block_id><sink_block_id>txOFDM_CyclicPrefix_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>txOFDM_OFDM_Modulation_0</source_block_id><sink_block_id>txOFDM_IFFT_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>txOFDM_SynchDataMux_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>txOFDM_random_bit_source_0</source_block_id><sink_block_id>txOFDM_ConstellationModulation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
